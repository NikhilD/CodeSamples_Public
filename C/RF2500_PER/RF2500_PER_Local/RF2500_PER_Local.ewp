# IAR project RF2500_PER_Local.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.newCCIncludePaths: hal\hal_exp430\; hal\include\; hal\common\; radio\
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    hal/hal_exp430/: hal_board.c hal_digio.c hal_led.c hal_mcu.c
    hal/common/: hal_int.c hal_rf.c hal_spi.c hal_spi_config.c timer.c
    c/: main.c usart.c
    radio/: radio.c
