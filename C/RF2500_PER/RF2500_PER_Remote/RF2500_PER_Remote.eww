<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RF2500_PER_Remote.ewp</path>
  </project>
  <batchBuild/>
</workspace>


